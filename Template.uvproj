# Keil uVision project Template.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\App\led;.\App\24cxx;.\App\beep;.\App\flash;.\App\iic;.\App\key;.\App\spi;.\App\sram;.\App\tim;.\App\touch;.\Malloc;.\App\smg;.\App\can;.\App\esp8266\ESP8266_drive;.\App\esp8266\ESP8266_Public;.\App\esp8266\STA_TCPClent_Test;.\App\DS18B20;.\App\gui;.\App\DHT11;.\Public;.\App\lcd1;.\App\shengyin
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_can.c
  group App
    ./App/led/: led.c
    ./App/beep/: beep.c
    ./App/key/: key.c
    ./App/DS18B20/: ds18b20.c
    ./App/DHT11/: dht11.c
    ./App/gui/: gui.c
    ./App/lcd1/: lcd_driver.c
    ./App/shengyin/: shengyin.c
  group Public
    ./Public/: system.c SysTick.c usart.c sys.c
  group ESP8266
    ./App/esp8266/ESP8266_drive/: esp8266_drive.c
    ./App/esp8266/STA_TCPClent_Test/: sta_tcpclent_test.c
    ./App/esp8266/ESP8266_Public/: esp8266_public.c
